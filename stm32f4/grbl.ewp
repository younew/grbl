# IAR project grbl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..; Libraries\CMSIS\Device\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: grbl.out
  ILINK.IlinkIcfFile: stm32f4xx_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../: coolant_control.c eeprom.c gcode.c limits.c main.c motion_control.c nuts_bolts.c planner.c print.c protocol.c report.c serial.c settings.c spindle_control.c stepper.c
